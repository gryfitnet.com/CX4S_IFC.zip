Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2019-06-07T15:02:38
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Alternate UI 18.0.0.420
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Jun 07 15:02:38 2019 * Host: DESKTOP-088PFGA * Database: C:\Users\KOMORO~1\AppData\Local\Temp\{3A5FF02F-8A46-4CB9-9112-2FA09B414ABD}\ifc * Database version: 5507 * Database creation date: Fri Jun 07 15:02:37 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Jun 07 15:02:37 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Jun 07 15:02:37 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 12, 46, 799999; RefLongitude: -71, -1, -58, -799999; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: GRYFIT CX-4S, female collar, D=100 + WT72C, D=100. P=145, GRYFIT CX-4S, Przeciwpożarowa klapa odcinająca:GRYFIT CX-4S, female collar, D=100 + WT72C, D=100. P=145:922390
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT CX-4S, female collar, D=100 + WT72C, D=100. P=145

# IfcBuildingElementProxy: GRYFIT CX-4S, female collar, D=125 + WT72C, D=125. P=145, GRYFIT CX-4S, Przeciwpożarowa klapa odcinająca:GRYFIT CX-4S, female collar, D=125 + WT72C, D=125. P=145:922391
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT CX-4S, female collar, D=125 + WT72C, D=125. P=145

# IfcBuildingElementProxy: GRYFIT CX-4S, female collar, D=160 + WT72C, D=160. P=145, GRYFIT CX-4S, Przeciwpożarowa klapa odcinająca:GRYFIT CX-4S, female collar, D=160 + WT72C, D=160. P=145:922392
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT CX-4S, female collar, D=160 + WT72C, D=160. P=145

# IfcBuildingElementProxy: GRYFIT CX-4S, female collar, D=200 + WT72C, D=200. P=145, GRYFIT CX-4S, Przeciwpożarowa klapa odcinająca:GRYFIT CX-4S, female collar, D=200 + WT72C, D=200. P=145:922393
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT CX-4S, female collar, D=200 + WT72C, D=200. P=145

# IfcBuildingElementProxy: GRYFIT CX-4S, male collar, D=100 + WT72C, D=100. P=190, GRYFIT CX-4S (2), Przeciwpożarowa klapa odcinająca:GRYFIT CX-4S, male collar, D=100 + WT72C, D=100. P=190:922394
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT CX-4S, male collar, D=100 + WT72C, D=100. P=190

# IfcBuildingElementProxy: GRYFIT CX-4S, male collar, D=125 + WT72C, D=125. P=190, GRYFIT CX-4S (2), Przeciwpożarowa klapa odcinająca:GRYFIT CX-4S, male collar, D=125 + WT72C, D=125. P=190:922395
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT CX-4S, male collar, D=125 + WT72C, D=125. P=190

# IfcBuildingElementProxy: GRYFIT CX-4S, male collar, D=160 + WT72C, D=160. P=190, GRYFIT CX-4S (2), Przeciwpożarowa klapa odcinająca:GRYFIT CX-4S, male collar, D=160 + WT72C, D=160. P=190:922396
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT CX-4S, male collar, D=160 + WT72C, D=160. P=190

# IfcBuildingElementProxy: GRYFIT CX-4S, male collar, D=200 + WT72C, D=200. P=190, GRYFIT CX-4S (2), Przeciwpożarowa klapa odcinająca:GRYFIT CX-4S, male collar, D=200 + WT72C, D=200. P=190:922397
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT CX-4S, male collar, D=200 + WT72C, D=200. P=190
